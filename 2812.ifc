Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-24T22:55:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 24 22:55:18 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{782A0B5A-A1E9-4634-9804-6D832B65B45E}\ifc * Database version: 5507 * Database creation date: Fri Aug 24 22:55:18 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 24 22:55:18 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 24 22:55:18 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 2812 Washbasin faucet, 2812:2812 Washbasin faucet:350041
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass, Fine Textured - Black
Type - Dimensions(Type) - FaucetNominalDepth: 145.5 mm; FaucetNominalHeight: 166 mm; FaucetNominalWidth: 50 mm; HandShowerNominalDepth: 37 mm; HandShowerNominalHeight: 286.5 mm; HandShowerNominalWidth: 32 mm; InletConnectionSize: 10 mm; Projection: 110 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 2812; ConvergoRefNr: 0087-1809-0117-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for washbasins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 23/08/2018
Type - Green Building Properties(Type) - EAN Number: 6414150058240; EN Standard: EN 817; ETA-Danmark: VA 1.42/17873; LVI Number: 6118770; Noise Class: I (ISO 3822); RSK Number: 8347850; Sintef Certificate: Sintef Nr. 1322; STF Certificate: VTT-RTH-04951-08; VVS Number: 703904104
Type - Identity Data(Type) - Class: Single lever; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;POL;RUS;SWE;UKR; Model: 2812 Washbasin faucet; Name_en: 2812 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2812; Product Datasheet: https://www.oras.com/datasheet/2812/en; Product Family: Oras Cubista; Product URL: https://www.oras.com/en/products/oras/product/2812; Type Name: 2812 Washbasin faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Aerator: HONEYCOMB®; Connection Size: Ø10 mm; Flow Rate At 300kPa: 0.00494405 m3/s; Hand Shower: Bidetta handshower; Installation and Maintenance: https://www.oras.com/fileadmin/resources/109791_PDM_943013_F_(943013-01-16).pdf; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 01ls: 140000 Pa; Shower Parts: Shower holder, shower hose; Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP2810/; Spout Type: Fixed spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2812; Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2812; Name: 2812 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:50x145x165 mm / Hand shower: 30x35x290 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 2812; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 2812 Washbasin faucet
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0617793 m2; Volume: 0.00155158 m3
Identity Data - Mark: 18
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 2812: 2812 Washbasin faucet; Family and Type: 2812: 2812 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2812: 2812 Washbasin faucet; Type Id: 2812: 2812 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
